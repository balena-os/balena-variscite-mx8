LED_FILE:imx8m-var-dart = "/sys/class/leds/led2/brightness"
