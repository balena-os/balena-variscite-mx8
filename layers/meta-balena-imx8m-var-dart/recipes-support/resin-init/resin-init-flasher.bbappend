INTERNAL_DEVICE_KERNEL_imx8m-var-dart = "mmcblk0"
INTERNAL_DEVICE_KERNEL_imx8mm-var-dart = "mmcblk2"
