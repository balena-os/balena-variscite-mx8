# Override branch name, as it has been renamed from
# master to main
SRC_URI = "git://github.com/intel/${BPN};branch=main;protocol=https"
