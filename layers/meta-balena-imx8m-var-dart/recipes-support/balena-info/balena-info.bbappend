TTYS:append:imx8m-var-dart = " ttymxc0"
TTYS:append:imx8mm-var-dart = " ttymxc0"
