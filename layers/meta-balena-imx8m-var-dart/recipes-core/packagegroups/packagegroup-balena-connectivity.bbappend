CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-bcm43143"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-135-6"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-3160"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-6000-4"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-6000g2a-6"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-6000g2b-6"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-6050-5"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-7260"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-7265"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-7265d"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-8000c"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-8265"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-iwlwifi-9260"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-rtl8188eu"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-wl12xx"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "linux-firmware-wl18xx"
CONNECTIVITY_FIRMWARES:remove:imx8mm-var-dart = "wireless-regdb-static"
CONNECTIVITY_FIRMWARES:append = " linux-firmware-bcm4339 "
