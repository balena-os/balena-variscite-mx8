# This fixes circular dependency error
IMAGE_FSTYPES_imx8m-var-dart  = "${INITRAMFS_FSTYPES}"
