TTYS_append_imx8m-var-dart = " ttymxc0"
