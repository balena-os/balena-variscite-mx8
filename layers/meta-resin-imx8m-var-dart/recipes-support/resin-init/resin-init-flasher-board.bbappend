FILESEXTRAPATHS_append_var-som-mx6 := "${THISDIR}/${PN}-var-som-mx6"
