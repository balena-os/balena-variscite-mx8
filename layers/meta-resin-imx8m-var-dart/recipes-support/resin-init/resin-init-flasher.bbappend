# On Variscite DART 6UL we flash Resin IO on the emmc
INTERNAL_DEVICE_KERNEL_imx6ul-var-dart = "mmcblk1"
INTERNAL_DEVICE_KERNEL_var-som-mx6 = "mmcblk0"
INTERNAL_DEVICE_KERNEL_imx7-var-som = "mmcblk2"
INTERNAL_DEVICE_KERNEL_imx8m-var-dart = "mmcblk0"
